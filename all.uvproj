# Keil uVision project all.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2119 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: all +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s timer.c header.h config.c main.c uart0_driver.c uart1_driver.c lcd4bit_driver.c adc_driver.c lcd8bit_driver.c
